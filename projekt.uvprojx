# Keil uVision project projekt.uvprojx, settings and files
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IRAM(0x1FFFE000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: projekt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    C:/Users/Mateusz/Desktop/projekt_SMPII/projekt_SMPII/: uart.c uart.h
    ./: main.c lowpower.c lowpower.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
